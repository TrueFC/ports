--- arch/arm/dts/rk3399.dtsi.org	2021-02-03 10:03:46.866514000 +0900
+++ arch/arm/dts/rk3399.dtsi	2021-02-03 10:13:16.580253000 +0900
@@ -1362,7 +1362,7 @@
 			<&cru HCLK_PERILP1>, <&cru PCLK_PERILP1>,
 			<&cru ACLK_VIO>, <&cru ACLK_HDCP>,
 			<&cru ACLK_GIC_PRE>,
-			<&cru PCLK_DDR>;
+			<&cru PCLK_DDR>, <&cru ACLK_VOP1>;
 		assigned-clock-rates =
 			 <594000000>,  <800000000>,
 			<1000000000>,
@@ -1373,7 +1373,7 @@
 			 <100000000>,   <50000000>,
 			 <400000000>, <400000000>,
 			 <200000000>,
-			 <200000000>;
+			 <200000000>, <594000000>;
 	};
 
 	grf: syscon@ff770000 {
@@ -1604,13 +1604,13 @@
 			#address-cells = <1>;
 			#size-cells = <0>;
 
-			vopl_out_mipi: endpoint@0 {
-				reg = <0>;
+			vopl_out_mipi: endpoint@1 {
+				reg = <1>;
 				remote-endpoint = <&mipi_in_vopl>;
 			};
 
-			vopl_out_edp: endpoint@1 {
-				reg = <1>;
+			vopl_out_edp: endpoint@0 {
+				reg = <0>;
 				remote-endpoint = <&edp_in_vopl>;
 			};
 
